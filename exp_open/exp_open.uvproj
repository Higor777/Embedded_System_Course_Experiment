# Keil uVision project exp_open.uvproj, settings and files
target exp_open (ARM-ADS)
  device: LPC2378 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: exp_open +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\User
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source
    ./User/: main.c wave.c timer.c oled.c key.c da.c ui.c
    ./: LPC2300.s
